# Keil uVision project project.uvproj, settings and files
target project (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: project +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\StdPeriphDriver\inc;.\Users\Inc;.\Uenc28j60\inc;.\uip\unix;.\uip\apps\webserver;.\uip\uip;.\uip\lib;.\uip\apps\hello-world;.\uip\apps\webclient;.\uip\apps\resolv
  asm include: .\FreeRTOS\Source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\Scatter\project.sct
  group CMSIS
    ./CMSIS/: system_stm32f10x.c core_cm3.c
  group StdPeriphDriver
    ./StdPeriphDriver/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c misc.c stm32f10x_dma.c stm32f10x_spi.c
  group StartUp
    ./StartUp/: startup_stm32f10x_md.s
  group User
    ./Users/Src/: stm32f10x_it.c main.c u_uart.c u_sys.c u_led.c u_spi.c
  group u_enc28j60
    ./Uenc28j60/src/: ENC28J60.C ip_arp_udp_tcp.c simple_server.c
  group uip
    ./uip/uip/: psock.c timer.c uip.c uip_arp.c uip-fw.c uiplib.c uip-neighbor.c
    ./uip/unix/: clock-arch.c tapdev.c
    ./uip/lib/: memb.c
