# Keil uVision project project.uvproj, settings and files
target project (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: project +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\StdPeriphDriver\inc;.\Users\Inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\Scatter\project.sct
  group CMSIS
    ./CMSIS/: system_stm32f10x.c core_cm3.c
  group StdPeriphDriver
    ./StdPeriphDriver/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c misc.c
  group StartUp
    ./StartUp/: startup_stm32f10x_md.s
  group User
    ./Users/Src/: stm32f10x_it.c main.c led.c u_uart.c u_sys.c
